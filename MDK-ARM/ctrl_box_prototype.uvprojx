# Keil uVision project ctrl_box_prototype.uvprojx, settings and files
target ctrl_box_F767 (6140000::V6.14::ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: ctrl_box_prototype +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\Core\Hardware;..\Core\RT_Thread\include;..\Core\RT_Thread\include\libc;..\Core\RT_Thread\user;..\Core\RT_Thread\components\finsh;..\Core\board;..\Core\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
    ../Core/RT_Thread/user/: board.c rtconfig.h
  group BSP/Config
    ../Core/BSP/: LC_tech_F767.c bsp_config.h
  group PrivateCode
    ../Core/Hardware/: myconsole.c controller.c
    ../Core/board/: IO_def.c
  group Hardware
    ../Core/Hardware/: sys.c led.c
  group RT/source
    ../Core/RT_Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT/Ports
    ../Core/RT_Thread/libcpu/arm/cortex-m7/: context_rvds.S cpuport.c
  group RT/Components
    ../Core/RT_Thread/components/finsh/: cmd.c msh.c shell.c
  group Drivers/STM32F7xx_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c
  group Drivers/CMSIS_F7
    ../Core/Src/: system_stm32f7xx.c
    ./: startup_stm32f767xx.s
target f103 (6120000::V6.12::.\ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ctrl_box_prototype +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.2.0
